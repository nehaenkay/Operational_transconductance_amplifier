*** netlisting can be given as

.include cmos_130nm.txt

M13 9 1 vdd vdd PMOS          W= 23.64375U L= 0.8U
M14 Vout 1 vdd vdd PMOS       W= 23.64375U L= 0.8U
M10 Vout 8 vdd vdd PMOS       W= 51.76U L= 0.6U
M9 9 2 vdd vdd PMOS           W= 51.76U L= 0.6U
M7 6 1 vdd vdd PMOS           W= 162.65U L= 0.8U
M8 7 1 vdd vdd PMOS           W= 162.65U L= 0.8U
M5 2 u 6 6 PMOS             W= 130.12U L= 1U
M6 8 u 7 7 PMOS             W= 130.12U L= 1U
M11 9 p 0 0 NMOS            W= 4.25U L= 1U
M12 Vout p 0 0 NMOS         W= 4.25U L= 1U
M3 2 p 3 0 NMOS             W= 54.97U L= 0.75U
M4 8 p 4 0 NMOS             W= 54.97U L= 0.75U
M1 3 Vin1 5 0 NMOS            W= 137.43U L= 0.3U
M2 4 Vin2 5 0 NMOS            W= 137.43U L= 0.3U

* netlist for VBIAS1,2,3 and IB1,3

M18 p r q 0 NMOS          W= 2U L= 1U
M19 q q 0 0 NMOS             W= 1.92918U L= 1U
M20 u t v 0 NMOS          W= 10U L= 1U
M21 v v 0 0 NMOS             W= 11.08429U L= 1U
Mref1 e e 0 0 NMOS          W= 1.15825U L= 1U
M16 5 e 0 0 NMOS             W= 36.75U L= 1U
M17 Vout e 0 0 NMOS             W= 5.753U L= 1U
M22 9 e 0 0 NMOS             W= 5.753U L= 1U

*resistor
R1  2 1 2000k
R2  1 8 2000k
RZright  8 10 30k
RZleft  2 11 30k
RBright  u 12 20k
RBleft  u 13 20k
R18  r p 7564
R20  t u 7564

*capacitor
CZright 10 Vout 0.8p
CZleft 11 9 0.8p
CLr Vout 0 0.5p
CLl 9 0 0.5p
CBright 8 12 200f
CBleft 2 13 200f

*supply**
V1 vdd 0 1.5

* Iref required for constant current mirror*
Iref vdd  e 50U
Iref1 vdd  r 50U
Iref2 vdd  t 50U

** given value of Vcm to be used to calculate parameters**
VG1 Vin1 0 0.76 ac 1
VG2 Vin2 0 0.74 ac 1

.control
op
set xbrushwidth = 2
print v(vout)

ac dec 100 1 10G
plot vdb(vout)
plot (180/pi)*phase(Vout)

.endc
.end
